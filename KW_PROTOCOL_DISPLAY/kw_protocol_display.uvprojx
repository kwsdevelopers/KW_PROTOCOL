# Keil uVision project kw_protocol_display.uvprojx, settings and files
target KW_PROTOCOL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F407AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kw_protocol
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER
  c include: .\inc;.\kw_protocol
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ./: main.c
    ./src/: init.c at32f403a_407_clock.c sys_timer.c kw_can.c
  group kw_protocol
    ./kw_protocol/: kw_protocol.c kw_proto_module_display.c kw_proto_module_kip6.c kw_proto_module_power.c kw_proto_vars_display.c kw_proto_vars_kip6.c kw_proto_vars_power.c kw_proto_pack_unpack.c kw_proto_vars.c kw_proto_sys.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0, Device:at32f403a_407_conf 2.0.0, Device:at32f403a_407_firmware_library:acc 2.0.0, Device:at32f403a_407_firmware_library:adc 2.0.0, Device:at32f403a_407_firmware_library:bpr 2.0.0, Device:at32f403a_407_firmware_library:can 2.0.0, Device:at32f403a_407_firmware_library:crc 2.0.0, Device:at32f403a_407_firmware_library:crm 2.0.0, Device:at32f403a_407_firmware_library:dac 2.0.0, Device:at32f403a_407_firmware_library:debug 2.0.0, Device:at32f403a_407_firmware_library:dma 2.0.0, Device:at32f403a_407_firmware_library:emac 2.0.0, Device:at32f403a_407_firmware_library:exint 2.0.0, Device:at32f403a_407_firmware_library:flash 2.0.0, Device:at32f403a_407_firmware_library:gpio 2.0.0, Device:at32f403a_407_firmware_library:i2c 2.0.0, Device:at32f403a_407_firmware_library:misc 2.0.0, Device:at32f403a_407_firmware_library:pwc 2.0.0, Device:at32f403a_407_firmware_library:rtc 2.0.0, Device:at32f403a_407_firmware_library:spi 2.0.0, Device:at32f403a_407_firmware_library:tmr 2.0.0, Device:at32f403a_407_firmware_library:usart 2.0.0, Device:at32f403a_407_firmware_library:usb 2.0.0, Device:at32f403a_407_firmware_library:wdt 2.0.0, Device:at32f403a_407_firmware_library:wwdt 2.0.0, Device:at32f403a_407_firmware_library:xmc 2.0.0
